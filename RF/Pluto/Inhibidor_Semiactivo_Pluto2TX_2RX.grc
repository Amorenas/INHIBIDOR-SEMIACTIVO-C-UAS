options:
  parameters:
    author: Nico García-Amorena
    comment: |-
      Barrido chirp 2.400-2.420 GHz + Beamforming 2 antenas
      PlutoSDR+ (2TX): Antena1=fase 0, Antena2=fase phi (slider)
      Preparado para DOA con segundo PlutoSDR (futuro)
      Separacion antenas: lambda = 12.5 cm @ 2.4 GHz
    description: Chirp Sweep + Beamforming 2 antenas PlutoSDR+
    generate_options: qt_gui
    id: pluto_beamforming_sweep
    output_language: python
    title: Chirp Sweep + Beamforming 2.4 GHz
  states: {}

blocks:
- name: ant_separation
  id: variable
  parameters:
    comment: |-
      Separacion antenas: lambda/2 @ 2.4GHz = 0.0625 m
      Optimo para beamforming sin grating lobes
    value: '0.0625'
  states: {}
- name: beam_angle_deg
  id: variable_qtgui_range
  parameters:
    comment: |-
      Angulo de apuntamiento del haz en grados.
      FUTURO: sera sobreescrito por el estimador DOA
      del segundo PlutoSDR receptor.
    gui_hint: 0,0,1,1
    label: Angulo Beamforming (grados)
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
    widget: slider
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Centro del rango de barrido (2.410 GHz)
    value: '2410000000'
  states: {}
- name: phase_shift
  id: variable
  parameters:
    comment: |-
      Desfase beamforming ULA 2 antenas.
      NOTA: recalcular o usar callback para tiempo real.
      phi = 2*pi*(d/lambda)*sin(theta)
    value: 2*math.pi*(ant_separation/0.125)*math.sin(math.radians(beam_angle_deg))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 20 MSPS necesario para cubrir 20 MHz de barrido
    value: '20000000'
  states: {}
- name: sweep_bw
  id: variable
  parameters:
    comment: 'Ancho de barrido: 20 MHz (2.400 a 2.420 GHz)'
    value: '20000000'
  states: {}
- name: sweep_time
  id: variable
  parameters:
    comment: Duracion de un ciclo de barrido en segundos
    value: '0.490'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: Ganancia TX PlutoSDR+ en dB
    value: '0'
  states: {}
- name: chirp_source
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Generador de Chirp Continuo para barrido de frecuencia.
          
          Genera señal compleja cuya frecuencia varia linealmente:
              f(t) = -BW/2  →  +BW/2  en sweep_time segundos
          
          La portadora del PlutoSDR+ se fija en center_freq.
          El chirp en banda base produce el barrido RF:
              2.400 GHz  →  2.420 GHz
          """

          def __init__(self, sample_rate=20000000, sweep_bw=20000000, sweep_time=0.490, amplitude=0.9):
              gr.sync_block.__init__(
                  self,
                  name='Chirp Sweep Source',
                  in_sig=None,
                  out_sig=[np.complex64],
              )
              self.sample_rate = sample_rate
              self.sweep_bw    = sweep_bw
              self.sweep_time  = sweep_time
              self.amplitude   = amplitude
              self.samples_per_sweep = int(sample_rate * sweep_time)
              self.chirp_rate = sweep_bw / self.samples_per_sweep
              self.sample_idx = 0

          def work(self, input_items, output_items):
              n = len(output_items[0])
              idx = np.arange(self.sample_idx, self.sample_idx + n)
              pos = idx % self.samples_per_sweep
              # Fase cuadratica: garantiza continuidad y barrido lineal
              phase = 2 * np.pi * (
                  (self.chirp_rate / (2 * self.sample_rate)) * pos**2
                  - (self.sweep_bw / (2 * self.sample_rate)) * pos
              )
              output_items[0][:n] = (self.amplitude * np.exp(1j * phase)).astype(np.complex64)
              self.sample_idx += n
              return n
    amplitude: '0.9'
    comment: |-
      CHIRP SOURCE
      Genera barrido continuo -10MHz a +10MHz
      en banda base.
      Con portadora en 2.410 GHz produce:
      2.400 GHz → 2.420 GHz en RF
    sample_rate: samp_rate
    sweep_bw: sweep_bw
    sweep_time: sweep_time
  states: {}
- name: doa_estimator_future
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          FUTURO: Estimador DOA para segundo PlutoSDR receptor.
          
          Algoritmo: MUSIC (MUltiple SIgnal Classification)
          Entrada: señal IQ del PlutoSDR receptor
          Salida: angulo estimado en radianes → alimenta phase_shift
          
          Para habilitar:
          1. Conectar PlutoSDR RX a la entrada de este bloque
          2. Conectar salida a variable beam_angle_deg
          3. El slider pasa a modo visualizacion
          
          Separacion antenas RX: lambda = 12.5 cm @ 2.4 GHz
          """

          def __init__(self, sample_rate=20000000, ant_separation=0.125, freq=2410000000):
              gr.sync_block.__init__(
                  self,
                  name='DOA Estimator (MUSIC)',
                  in_sig=[np.complex64],
                  out_sig=[np.float32],  # angulo en grados
              )
              self.sample_rate = sample_rate
              self.ant_separation = ant_separation
              self.wavelength = 3e8 / freq
              self.buffer = []
              self.buffer_size = 1024

          def work(self, input_items, output_items):
              """
              PENDIENTE DE IMPLEMENTACION:
              - Acumular muestras del PlutoSDR RX
              - Calcular matriz de covarianza R = E[x*x^H]
              - Aplicar MUSIC: eigendescomposicion de R
              - Buscar pico en espectro espacial MUSIC
              - Retornar angulo en grados
              """
              n = len(input_items[0])
              # Placeholder: retorna 0 grados hasta implementacion real
              output_items[0][:n] = np.zeros(n, dtype=np.float32)
              return n
    ant_separation: ant_separation
    comment: |-
      FUTURO: DOA con segundo PlutoSDR
      ALGORITMO: MUSIC
      ENTRADA: IQ del PlutoSDR RX
      SALIDA: angulo estimado → beam_angle_deg
      ESTADO: DESHABILITADO hasta tener 2º Pluto
    freq: center_freq
    sample_rate: samp_rate
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: '10'
    bandwidth: samp_rate
    buffer_size: '32768'
    comment: |-
      PLUTOSDR+ TX 2TX/2RX (firmware hack)
      fmcomms2_sink expone TX1 y TX2 del AD9363 desbloqueado.
      Canal 0 → TX1 (Antena 1, fase 0 grados)
      Canal 1 → TX2 (Antena 2, fase phi - beamforming)
      URI: ip:192.168.2.1
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'True'
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_numpy
  id: import
  parameters:
    alias: np
    imports: import numpy as np
  states: {}
- name: multiply_const_ant1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      ANTENA 1
      Fase = 0 grados (referencia)
      Sin modificacion de fase
    const: '1.0'
    type: complex
  states: {}
- name: multiply_const_ant2
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      ANTENA 2
      Aplica desfase de beamforming:
      phi = 2*pi*sin(theta)
      Controlado por slider (futuro: DOA)
    const: np.exp(1j * phase_shift)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"yellow"'
    color2: '"cyan"'
    comment: |-
      VISUALIZACION ESPECTRO
      Muestra el chirp en tiempo real
      Amarillo=Ant1, Cyan=Ant2
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    label: Espectro TX
    label1: Antena 1
    label2: Antena 2
    name: '"Chirp Sweep - Barrido 2.400-2.420 GHz"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
    width1: '2'
    width2: '2'
  states: {}
- name: throttle_ant1
  id: blocks_throttle2
  parameters:
    comment: 'SIMULACION: deshabilitado para uso con PlutoSDR real'
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [chirp_source, '0', multiply_const_ant1, '0']
- [chirp_source, '0', multiply_const_ant2, '0']
- [multiply_const_ant1, '0', iio_pluto_sink_0, '0']
- [multiply_const_ant1, '0', qtgui_freq_sink_x_0, '0']
- [multiply_const_ant2, '0', iio_pluto_sink_0, '1']
- [multiply_const_ant2, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
