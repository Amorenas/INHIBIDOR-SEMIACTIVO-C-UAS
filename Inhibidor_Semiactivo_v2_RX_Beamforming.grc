options:
  parameters:
    author: Nico García-Amorena
    comment: |-
      Barrido chirp 2.400-2.420 GHz + Beamforming 2 antenas
      PlutoSDR+ (2TX): Antena1=fase 0, Antena2=fase phi (slider)
      Preparado para DOA con segundo PlutoSDR (futuro)
      Separacion antenas: lambda = 12.5 cm @ 2.4 GHz
    description: Chirp Sweep + Beamforming 2 antenas PlutoSDR+
    generate_options: qt_gui
    id: pluto_beamforming_sweep
    output_language: python
    title: Chirp Sweep + Beamforming 2.4 GHz
  states: {}

blocks:
- name: ant_separation
  id: variable
  parameters:
    comment: |-
      Separacion antenas: lambda/2 @ 2.4GHz = 0.0625 m
      Optimo para beamforming sin grating lobes
    value: '0.0625'
  states: {}
- name: beam_angle_deg
  id: variable_qtgui_range
  parameters:
    comment: |-
      Angulo de apuntamiento del haz en grados.
      FUTURO: sera sobreescrito por el estimador DOA
      del segundo PlutoSDR receptor.
    gui_hint: 0,0,1,1
    label: Angulo Beamforming (grados)
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
    widget: slider
  states: {}
- name: beam_angle_from_doa
  id: variable_function_probe
  parameters:
    block_id: my_block_0
    comment: |-
      Binding DOA → beam_angle_deg
      Actualiza el angulo TX automaticamente
      cuando el estimador MUSIC entrega nuevo valor
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    comment: Centro del rango de barrido (2.410 GHz)
    value: '2410000000'
  states: {}
- name: doa_angle_deg
  id: variable
  parameters:
    comment: Angulo DOA estimado en grados (actualizado por MUSIC EPyBlock)
    value: '0'
  states: {}
- name: null_angle_deg
  id: variable_qtgui_range
  parameters:
    comment: Angulo de nulificacion (null steering TX)
    gui_hint: 0,1,1,1
    label: Angulo Nulo TX (grados)
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
    widget: slider
  states: {}
- name: phase_shift
  id: variable
  parameters:
    comment: |-
      Desfase beamforming ULA 2 antenas.
      NOTA: recalcular o usar callback para tiempo real.
      phi = 2*pi*(d/lambda)*sin(theta)
    value: 2*math.pi*(ant_separation/0.125)*math.sin(math.radians(beam_angle_deg))
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Ganancia RX PlutoSDR sensor en dB
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 20 MSPS necesario para cubrir 20 MHz de barrido
    value: '20000000'
  states: {}
- name: sweep_bw
  id: variable
  parameters:
    comment: 'Ancho de barrido: 20 MHz (2.400 a 2.420 GHz)'
    value: '20000000'
  states: {}
- name: sweep_time
  id: variable
  parameters:
    comment: Duracion de un ciclo de barrido en segundos
    value: '0.490'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: Ganancia TX PlutoSDR+ en dB
    value: '0'
  states: {}
- name: chirp_source
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Generador de Chirp Continuo para barrido de frecuencia.
          
          Genera señal compleja cuya frecuencia varia linealmente:
              f(t) = -BW/2  →  +BW/2  en sweep_time segundos
          
          La portadora del PlutoSDR+ se fija en center_freq.
          El chirp en banda base produce el barrido RF:
              2.400 GHz  →  2.420 GHz
          """

          def __init__(self, sample_rate=20000000, sweep_bw=20000000, sweep_time=0.490, amplitude=0.9):
              gr.sync_block.__init__(
                  self,
                  name='Chirp Sweep Source',
                  in_sig=None,
                  out_sig=[np.complex64],
              )
              self.sample_rate = sample_rate
              self.sweep_bw    = sweep_bw
              self.sweep_time  = sweep_time
              self.amplitude   = amplitude
              self.samples_per_sweep = int(sample_rate * sweep_time)
              self.chirp_rate = sweep_bw / self.samples_per_sweep
              self.sample_idx = 0

          def work(self, input_items, output_items):
              n = len(output_items[0])
              idx = np.arange(self.sample_idx, self.sample_idx + n)
              pos = idx % self.samples_per_sweep
              # Fase cuadratica: garantiza continuidad y barrido lineal
              phase = 2 * np.pi * (
                  (self.chirp_rate / (2 * self.sample_rate)) * pos**2
                  - (self.sweep_bw / (2 * self.sample_rate)) * pos
              )
              output_items[0][:n] = (self.amplitude * np.exp(1j * phase)).astype(np.complex64)
              self.sample_idx += n
              return n
    amplitude: '0.9'
    comment: |-
      CHIRP SOURCE
      Genera barrido continuo -10MHz a +10MHz
      en banda base.
      Con portadora en 2.410 GHz produce:
      2.400 GHz → 2.420 GHz en RF
    sample_rate: samp_rate
    sweep_bw: sweep_bw
    sweep_time: sweep_time
  states: {}
- name: doa_estimator_future
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          FUTURO: Estimador DOA para segundo PlutoSDR receptor.
          
          Algoritmo: MUSIC (MUltiple SIgnal Classification)
          Entrada: señal IQ del PlutoSDR receptor
          Salida: angulo estimado en radianes → alimenta phase_shift
          
          Para habilitar:
          1. Conectar PlutoSDR RX a la entrada de este bloque
          2. Conectar salida a variable beam_angle_deg
          3. El slider pasa a modo visualizacion
          
          Separacion antenas RX: lambda = 12.5 cm @ 2.4 GHz
          """

          def __init__(self, sample_rate=20000000, ant_separation=0.125, freq=2410000000):
              gr.sync_block.__init__(
                  self,
                  name='DOA Estimator (MUSIC)',
                  in_sig=[np.complex64],
                  out_sig=[np.float32],  # angulo en grados
              )
              self.sample_rate = sample_rate
              self.ant_separation = ant_separation
              self.wavelength = 3e8 / freq
              self.buffer = []
              self.buffer_size = 1024

          def work(self, input_items, output_items):
              """
              PENDIENTE DE IMPLEMENTACION:
              - Acumular muestras del PlutoSDR RX
              - Calcular matriz de covarianza R = E[x*x^H]
              - Aplicar MUSIC: eigendescomposicion de R
              - Buscar pico en espectro espacial MUSIC
              - Retornar angulo en grados
              """
              n = len(input_items[0])
              # Placeholder: retorna 0 grados hasta implementacion real
              output_items[0][:n] = np.zeros(n, dtype=np.float32)
              return n
    ant_separation: ant_separation
    comment: |-
      FUTURO: DOA con segundo PlutoSDR
      ALGORITMO: MUSIC
      ENTRADA: IQ del PlutoSDR RX
      SALIDA: angulo estimado → beam_angle_deg
      ESTADO: DESHABILITADO hasta tener 2º Pluto
    freq: center_freq
    sample_rate: samp_rate
  states: {state: disabled}
- name: doa_music_rx
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Estimador DOA MUSIC para ULA de 2 elementos.

          Entradas:
              in0 (complex): señal RX antena 1 (referencia)
              in1 (complex): señal RX antena 2 (desfasada)

          Salida:
              out0 (float): angulo DOA estimado en GRADOS

          Algoritmo MUSIC simplificado para 2 elementos:
              - Calcula matriz de correlacion cruzada
              - Estima angulo por maxima correlacion
              - Suavizado exponencial para estabilidad

          Para arrays mayores usar scipy/numpy eigendec completo.
          """

          def __init__(self, sample_rate=20000000, ant_separation=0.0625,
                       freq=2410000000, smooth=0.05, block_size=1024):
              gr.sync_block.__init__(
                  self,
                  name='DOA MUSIC 2-element',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.float32],
              )
              self.sample_rate   = sample_rate
              self.ant_sep       = ant_separation
              self.wavelength    = 3e8 / freq
              self.smooth        = smooth          # coef. suavizado EMA
              self.block_size    = block_size
              self.set_output_multiple(block_size)

              # Grilla de angulos de busqueda
              self.angles_deg  = np.linspace(-90, 90, 361)
              self.angles_rad  = np.radians(self.angles_deg)

              # Vectores steering para cada angulo
              self.d_over_lam  = ant_separation / self.wavelength
              self.steering    = np.exp(
                  1j * 2 * np.pi * self.d_over_lam * np.sin(self.angles_rad)
              )  # shape (361,)

              self.doa_smooth  = 0.0   # estado interno suavizado

          def work(self, input_items, output_items):
              n = self.block_size
              x1 = input_items[0][:n]
              x2 = input_items[1][:n]

              # ── Matriz de correlacion cruzada (2x2) ──
              r11 = np.mean(x1 * np.conj(x1)).real
              r12 = np.mean(x1 * np.conj(x2))
              r21 = np.conj(r12)
              r22 = np.mean(x2 * np.conj(x2)).real
              R = np.array([[r11, r12],
                            [r21, r22]])

              # ── Eigendescomposicion ──
              eigvals, eigvecs = np.linalg.eigh(R)
              # Subespacio de ruido: eigenvector con menor eigenvalor
              noise_vec = eigvecs[:, 0]  # shape (2,)

              # ── Pseudoespectro MUSIC ──
              # a(theta) = [1, exp(j*2pi*(d/lam)*sin(theta))]
              a = np.stack([np.ones(361), self.steering], axis=0)  # (2, 361)
              # P_music(theta) = 1 / |a^H * En * En^H * a|
              En = noise_vec[:, np.newaxis]             # (2,1)
              proj = En @ En.conj().T                   # (2,2) noise projector
              denom = np.abs(
                  np.einsum('ij,jk,ki->i',
                            a.conj().T,   # (361,2)
                            proj,          # (2,2)
                            a)             # (2,361)
              ) + 1e-12
              music_spectrum = 1.0 / denom              # (361,)

              # ── Pico del espectro → angulo estimado ──
              peak_idx  = int(np.argmax(music_spectrum))
              doa_raw   = float(self.angles_deg[peak_idx])

              # ── Suavizado exponencial (EMA) ──
              self.doa_smooth = (
                  self.smooth * doa_raw +
                  (1.0 - self.smooth) * self.doa_smooth
              )

              output_items[0][:n] = np.full(n, self.doa_smooth, dtype=np.float32)
              return n
    ant_separation: ant_separation
    block_size: '1024'
    comment: |-
      DOA MUSIC 2 ELEMENTOS
      Entradas: RX1, RX2 del PlutoSDR sensor
      Salida: angulo en grados → beam_angle_deg
      Suavizado EMA=0.05 para estabilidad
      Grilla: -90 a +90 en 361 puntos (0.5 deg resolucion)
    freq: center_freq
    sample_rate: samp_rate
    smooth: '0.05'
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: samp_rate
    buffer_size: '32768'
    comment: |-
      PLUTOSDR+ TX - DESHABILITADO (modo simulacion)
      Para transmitir con hardware:
      1) Cambiar state a enabled
      2) Deshabilitar throttle_ant1
      3) Cambiar URI: ip:192.168.2.1 o usb:1.X.X
      Canal 0 → TX1 (Antena 1, fase 0)
      Canal 1 → TX2 (Antena 2, fase phi)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_rx
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '32768'
    comment: |-
      PLUTOSDR+ SENSOR RX
      URI: ip:192.168.3.1 (segundo Pluto — ajustar)
      Canal 0 → RX1 (Antena ref, fase 0)
      Canal 1 → RX2 (Antena desfasada, fase phi_rx)
      Coherencia garantizada por hardware PlutoSDR+
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''slow_attack'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {state: disabled}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_numpy
  id: import
  parameters:
    alias: np
    imports: import numpy as np
  states: {}
- name: multiply_const_ant1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      ANTENA 1
      Fase = 0 grados (referencia)
      Sin modificacion de fase
    const: '1.0'
    type: complex
  states: {}
- name: multiply_const_ant2
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      ANTENA 2
      Aplica desfase de beamforming:
      phi = 2*pi*sin(theta)
      Controlado por slider (futuro: DOA)
    const: np.exp(1j * phase_shift)
    type: complex
  states: {}
- name: null_steering_tx
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Null Steering para ULA de 2 antenas TX.

          Modifica los pesos de las dos antenas TX para
          colocar un nulo en la direccion null_angle_deg.

          Entradas:
              in0 (complex): señal TX (chirp) para antena 1
              in1 (complex): señal TX (chirp) para antena 2 (pre-beamforming)

          Salidas:
              out0 (complex): señal antena 1 con peso null steering
              out1 (complex): señal antena 2 con peso null steering

          El null steering se combina con el beamforming previo:
          w_null = I - a*a^H/||a||^2
          w_beam = [1, exp(j*phi)]
          w_total = w_null * w_beam
          """

          def __init__(self, sample_rate=20000000, ant_separation=0.0625,
                       freq=2410000000, null_angle_deg=0.0, beam_angle_deg=0.0):
              gr.sync_block.__init__(
                  self,
                  name='Null Steering 2-ant',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64, np.complex64],
              )
              self.ant_sep     = ant_separation
              self.wavelength  = 3e8 / freq
              self.null_angle  = null_angle_deg
              self.beam_angle  = beam_angle_deg
              self._update_weights()

          def _update_weights(self):
              d_lam = self.ant_sep / self.wavelength
              # Steering vector beamforming
              phi_beam = 2 * np.pi * d_lam * np.sin(np.radians(self.beam_angle))
              a_beam   = np.array([1.0, np.exp(1j * phi_beam)])

              # Steering vector null
              phi_null = 2 * np.pi * d_lam * np.sin(np.radians(self.null_angle))
              a_null   = np.array([1.0, np.exp(1j * phi_null)])

              # Proyector ortogonal al nulo
              # P_null = I - a_null * a_null^H / ||a_null||^2
              P_null = np.eye(2) - np.outer(a_null, a_null.conj()) / np.dot(a_null, a_null.conj()).real

              # Pesos finales
              w = P_null @ a_beam
              # Normalizar para mantener potencia
              norm = np.linalg.norm(w)
              if norm > 1e-9:
                  w = w / norm
              self.w0 = np.complex64(w[0])
              self.w1 = np.complex64(w[1])

          def set_null_angle_deg(self, val):
              self.null_angle = float(val)
              self._update_weights()

          def set_beam_angle_deg(self, val):
              self.beam_angle = float(val)
              self._update_weights()

          def work(self, input_items, output_items):
              n = len(output_items[0])
              output_items[0][:n] = input_items[0][:n] * self.w0
              output_items[1][:n] = input_items[1][:n] * self.w1
              return n
    ant_separation: ant_separation
    beam_angle_deg: beam_angle_deg
    comment: |-
      NULL STEERING TX
      Combina beamforming + null steering
      w_total = P_null * w_beam
      null_angle_deg: controlado por slider
      beam_angle_deg: del DOA automatico o slider manual
    freq: center_freq
    null_angle_deg: '0.0'
    sample_rate: samp_rate
  states: {state: disabled}
- name: probe_doa
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      Lee angulo DOA del estimador MUSIC.
      La variable beam_angle_deg se actualiza
      via callback cada 100 ms.
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_rx
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"cyan"'
    color2: '"magenta"'
    comment: |-
      ESPECTRO RX - Sensor DOA
      Cyan=RX1(ref), Magenta=RX2(desfasada)
      Permite verificar coherencia entre canales
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    label: Espectro RX Sensor
    label1: RX1 (ref)
    label2: RX2 (phi)
    name: '"Sensor RX - DOA 2.400-2.420 GHz"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"yellow"'
    color2: '"cyan"'
    comment: |-
      VISUALIZACION ESPECTRO
      Muestra el chirp en tiempo real
      Amarillo=Ant1, Cyan=Ant2
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    label: Espectro TX
    label1: Antena 1
    label2: Antena 2
    name: '"Chirp Sweep - Barrido 2.400-2.420 GHz"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_number_sink_doa
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    comment: |-
      DISPLAY ANGULO DOA
      Muestra en tiempo real el angulo estimado
      por el algoritmo MUSIC
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,2
    label1: DOA Estimado (grados)
    max: '90'
    min: '-90'
    name: '"Direccion de Llegada WiFi"'
    type: float
    unit1: deg
  states: {state: disabled}
- name: throttle_ant1
  id: blocks_throttle2
  parameters:
    comment: |-
      SIMULACION: habilitado
      Comentar/deshabilitar al usar PlutoSDR real
      Limita CPU en simulacion
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [chirp_source, '0', throttle_ant1, '0']
- [doa_music_rx, '0', probe_doa, '0']
- [doa_music_rx, '0', qtgui_number_sink_doa, '0']
- [iio_pluto_source_rx, '0', doa_music_rx, '0']
- [iio_pluto_source_rx, '0', qtgui_freq_sink_rx, '0']
- [multiply_const_ant1, '0', qtgui_freq_sink_x_0, '0']
- [multiply_const_ant2, '0', qtgui_freq_sink_x_0, '1']
- [throttle_ant1, '0', multiply_const_ant1, '0']
- [throttle_ant1, '0', multiply_const_ant2, '0']
- [throttle_ant1, '0', null_steering_tx, '0']
- [throttle_ant1, '0', null_steering_tx, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
